# IAR project DBG_DISP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F413C8 ArteryTek AT32F413C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ; board; include; ..\conf; ..\src\fmbport; source\hid; ..\src\udpserver; D:\SourceRespo\ChibiOS\chibios203\os\common\abstractions\cmsis_os; D:\SourceRespo\ChibiOS\chibios203\os\common\ext\ARM\CMSIS\Core\Include; D:\SourceRespo\ChibiOS\chibios203\os\common\ext\Artery; D:\SourceRespo\ChibiOS\chibios203\os\common\ports\ARMCMx\compilers\IAR; D:\SourceRespo\ChibiOS\chibios203\os\license; D:\SourceRespo\ChibiOS\chibios203\os\hal\include; D:\SourceRespo\ChibiOS\chibios203\os\hal\lib\streams; D:\SourceRespo\ChibiOS\chibios203\os\hal\osal\rt-nil; D:\SourceRespo\ChibiOS\chibios203\os\common\ports\ARMCMx; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\common\ARMCMx; D:\SourceRespo\ChibiOS\chibios203\os\common\startup\ARMCMx\devices\AT32F4xx; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\CANv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\DACv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\DMAv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\GPIOv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\I2Cv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\USBv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\RTCv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\SDIOv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\SPIv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\TIMv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\USARTv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\xWDGv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\AT32F4xxF1; D:\SourceRespo\ChibiOS\chibios203\os\rt\include; D:\SourceRespo\ChibiOS\chibios203\os\oslib\include; D:\SourceRespo\ChibiOS\chibios203\os\various\; D:\SourceRespo\ChibiOS\chibios203\os\various\cpp_wrappers; D:\SourceRespo\ChibiOS\chibios203\os\various\fatfs_bindings; D:\SourceRespo\ChibiOS\chibios203\os\various\shell; D:\SourceRespo\ylib\eeprom; D:\SourceRespo\ylib\numeric\time; D:\SourceRespo\ylib\protocol\bincmd; D:\SourceRespo\ylib\wireless\lora; D:\SourceRespo\ylib\sensor\ntc; D:\SourceRespo\ylib\network\udpserver; D:\SourceRespo\ylib\display; D:\SourceRespo\ChibiOS\chibios203\ext\lwip-2.1.2\lwip\src\include; D:\SourceRespo\ChibiOS\chibios203\os\various\lwip_bindings; D:\SourceRespo\ChibiOS\chibios203\community\os\hal\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ; board; include; D:\SourceRespo\ChibiOS\chibios203\os\license; D:\SourceRespo\ChibiOS\chibios203\os\common\ports\ARMCMx; D:\SourceRespo\ChibiOS\chibios203\os\common\startup\ARMCMx\devices\AT32F4xx
  OBJCOPY.OOCOutputFile: DBG_DISP_xxxxxxxxx.hex
  ILINK.IlinkOutputFile: DBG_DISP.out
  ILINK.IlinkIcfFile: ch_at32f413c8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Board
    board/: board.c board.h
  group ChiBIOS/2.0.3/community/os/hal/src
    $extsource$/ChibiOS/chibios203/community/os/hal/src/: hal_community.c hal_comp.c hal_crc.c hal_ee24xx.c hal_ee25xx.c hal_eeprom.c hal_eicu.c hal_fsmc.c hal_nand.c hal_onewire.c hal_opamp.c hal_qei.c hal_rng.c hal_sdram.c hal_sram.c hal_timcap.c hal_usb_hid.c hal_usb_msd.c hal_usbh.c
  group ChiBIOS/2.0.3/os/common/abstractions/cmsis_os
    $extsource$/ChibiOS/chibios203/os/common/abstractions/cmsis_os/: cmsis_os.c cmsis_os.h
  group ChiBIOS/2.0.3/os/common/ext/artery
    $extsource$/ChibiOS/chibios203/os/common/ext/Artery/: at32f4xx.h at32f4xx_acc.h at32f4xx_adc.h at32f4xx_bkp.h at32f4xx_can.h at32f4xx_comp.h at32f4xx_conf.h at32f4xx_crc.h at32f4xx_dac.h at32f4xx_dbgmcu.h at32f4xx_dma.h at32f4xx_ertc.h at32f4xx_exti.h at32f4xx_flash.h at32f4xx_gpio.h at32f4xx_i2c.h at32f4xx_iwdg.h at32f4xx_pwr.h at32f4xx_rcc.h at32f4xx_rtc.h at32f4xx_sdio.h at32f4xx_spi.h at32f4xx_tim.h at32f4xx_usart.h at32f4xx_wwdg.h at32f4xx_xmc.h misc.h system_at32f4xx.h
  group ChiBIOS/2.0.3/os/common/ports
    $extsource$/ChibiOS/chibios203/os/common/ports/ARMCMx/: chcore.c chcore.h chcore_timer.h chcore_v6m.c chcore_v6m.h chcore_v7m.c chcore_v7m.h mpu.h
  group ChiBIOS/2.0.3/os/common/ports/compiler
    $extsource$/ChibiOS/chibios203/os/common/ports/ARMCMx/compilers/IAR/: chcoreasm_v6m.s chcoreasm_v7m.s chtypes.h
  group ChiBIOS/2.0.3/os/common/startup
    $extsource$/ChibiOS/chibios203/os/common/startup/ARMCMx/devices/AT32F4xx/: cmparams.h
    $extsource$/ChibiOS/chibios203/os/common/startup/ARMCMx/compilers/IAR/: cstartup.s vectors.s
  group ChiBIOS/2.0.3/os/hal/lib/streams
    $extsource$/ChibiOS/chibios203/os/hal/lib/streams/: chprintf.c chprintf.h memstreams.c memstreams.h nullstreams.c nullstreams.h
  group ChiBIOS/2.0.3/os/hal/osal/rt-nil
    $extsource$/ChibiOS/chibios203/os/hal/osal/rt-nil/: osal.c osal.h
  group ChiBIOS/2.0.3/os/hal/ports/at32
    $extsource$/ChibiOS/chibios203/os/hal/ports/AT32ST/AT32F4xxF1/: hal_adc_lld.c hal_adc_lld.h hal_efl_lld.c hal_efl_lld.h hal_lld.c hal_lld.h hal_lld_f100.h hal_lld_f103.h hal_lld_f105_f107.h stm32_isr.c stm32_isr.h stm32_rcc.h stm32_registry.h
  group ChiBIOS/2.0.3/os/hal/ports/at32/lld/ADCv2
    $extsource$/ChibiOS/chibios203/os/hal/ports/AT32ST/LLD/ADCv2/: hal_adc_lld.c hal_adc_lld.h
  group ChiBIOS/2.0.3/os/hal/ports/at32/lld/CANv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/AT32ST/LLD/CANv1/: hal_can_lld.c hal_can_lld.h
  group ChiBIOS/2.0.3/os/hal/ports/at32/lld/DMAv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/AT32ST/LLD/DMAv1/: stm32_dma.c stm32_dma.h
  group ChiBIOS/2.0.3/os/hal/ports/at32/lld/GPIOv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/AT32ST/LLD/GPIOv1/: hal_pal_lld.c hal_pal_lld.h
  group ChiBIOS/2.0.3/os/hal/ports/at32/lld/I2Cv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/AT32ST/LLD/I2Cv1/: hal_i2c_lld.c hal_i2c_lld.h
  group ChiBIOS/2.0.3/os/hal/ports/at32/lld/RTCv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/AT32ST/LLD/RTCv1/: hal_rtc_lld.c hal_rtc_lld.h
  group ChiBIOS/2.0.3/os/hal/ports/at32/lld/SPIv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/AT32ST/LLD/SPIv1/: hal_i2s_lld.c hal_i2s_lld.h hal_spi_lld.c hal_spi_lld.h
  group ChiBIOS/2.0.3/os/hal/ports/at32/lld/TIMv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/AT32ST/LLD/TIMv1/: hal_gpt_lld.c hal_gpt_lld.h hal_icu_lld.c hal_icu_lld.h hal_pwm_lld.c hal_pwm_lld.h hal_st_lld.c hal_st_lld.h stm32_tim.h
  group ChiBIOS/2.0.3/os/hal/ports/at32/lld/USARTv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/AT32ST/LLD/USARTv1/: hal_serial_lld.c hal_serial_lld.h hal_uart_lld.c hal_uart_lld.h
  group ChiBIOS/2.0.3/os/hal/ports/at32/lld/USBv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/AT32ST/LLD/USBv1/: hal_usb_lld.c hal_usb_lld.h stm32_usb.h
  group ChiBIOS/2.0.3/os/hal/ports/common
    $extsource$/ChibiOS/chibios203/os/hal/ports/common/ARMCMx/: cache.h mpu_v7m.h nvic.c nvic.h
  group ChiBIOS/2.0.3/os/hal/src
    $extsource$/ChibiOS/chibios203/os/hal/src/: hal.c hal_adc.c hal_buffers.c hal_can.c hal_crypto.c hal_dac.c hal_efl.c hal_flash.c hal_gpt.c hal_i2c.c hal_i2s.c hal_icu.c hal_mac.c hal_mmc_spi.c hal_mmcsd.c hal_pal.c hal_pwm.c hal_queues.c hal_rtc.c hal_sdc.c hal_serial.c hal_serial_usb.c hal_sio.c hal_spi.c hal_st.c hal_trng.c hal_uart.c hal_usb.c hal_wdg.c hal_wspi.c
  group ChiBIOS/2.0.3/os/nil
    $extsource$/ChibiOS/chibios203/os/nil/src/: ch.c chevt.c chmsg.c chsem.c
  group ChiBIOS/2.0.3/os/oslib
    $extsource$/ChibiOS/chibios203/os/oslib/src/: chdelegates.c chfactory.c chmboxes.c chmemcore.c chmemheaps.c chmempools.c chobjcaches.c chpipes.c
  group ChiBIOS/2.0.3/os/rt
    $extsource$/ChibiOS/chibios203/os/rt/src/: chcond.c chdebug.c chdynamic.c chevents.c chmsg.c chmtx.c chregistry.c chschd.c chsem.c chstats.c chsys.c chthreads.c chtm.c chtrace.c chvt.c
  group ChiBIOS/2.0.3/os/various
    $extsource$/ChibiOS/chibios203/os/various/: evtimer.c evtimer.h syscalls.c
  group ChiBIOS/2.0.3/os/various/shell
    $extsource$/ChibiOS/chibios203/os/various/shell/: shell.c shell.h shell_cmd.c shell_cmd.h
  group Config
    include/: chconf.h halconf.h halconf_community.h mcuconf.h mcuconf_community.h
  group Source
    source/: main.c oled_disp.c
  group Source/Display
    $extsource$/ylib/display/: ssd1306.c ssd1306.h ssd1362.c ssd1362.h
  group Source/USB/CDC
    source/CDC/: usbcfg.c usbcfg.h
  group Source/USB/HID
    source/HID/: usbcfg.c usbcfg.h
